# IAR project STM32CubeMX.ewp, settings and files
configuration STM32CubeMX (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../../0_Common_Use; ../../1_Application; ../../3_Hardware_Core; ../../3_Hardware_Core/BSP; ../../3_Hardware_Core/Drivers/; ../../3_Hardware_Core/Drivers/inc; ../../3_Hardware_Core/startup; ../../STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Inc; ../../STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../STM32CubeMX/Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../STM32CubeMX/Drivers/CMSIS/Include; ..\..\0_Common_Use; ..\..\1_Application; ..\..\3_Hardware_Core\BSP; ..\..\3_Hardware_Core\startup
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32CubeMX.hex
  ILINK.IlinkOutputFile: STM32CubeMX.out
  ILINK.IlinkIcfFile: ../../3_Hardware_Core/startup/stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 1_Application
    ../../1_Application/: main.c
  group 3_Hardware_Core/BSP
    ../../3_Hardware_Core/BSP/: STM32F407ZET6.c
  group 3_Hardware_Core/Drivers
    ../../3_Hardware_Core/Drivers/src/: Button.c Buzzer.c FSMC.c GPIO.c I2C.c LCD.c led7seg.c spi.c Timer.c
  group 3_Hardware_Core/startup
    ../../3_Hardware_Core/startup/: startup_stm32f407xx.s stm32f407xx_flash.icf stm32f4xx_hal.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group 3_Hardware_Core/STM32F4xx_HAL_Driver
    ../../STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
